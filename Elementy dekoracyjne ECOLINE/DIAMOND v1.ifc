Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Elements to export: Selected elements only], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: Off]
File name: G:\!WORK\20240623-marbet modele 3d\seria 3\DIAMOND v1.ifc
Time: 2024-09-16T16:18:12
Author: Architect
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 27.0.0 POL FULL Windows version (IFC add-on version: 3001 POL FULL).
Authorization: The authorising person

# IfcSite, Lokalizacja
RefLatitude: 52, 15, 0, 0; RefLongitude: 21, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Poziom 0
In: Budynek
Elevation: 0 mm

# IfcFurnishingElement: DIAMOND v1, OB2
In: Poziom 0
Pset_FireRatingProperties - FireResistanceRating: -; IsCombustible: no
Pset_ManufacturerOccurrence - BarCode: -; SerialNumber: -
Pset_ManufacturerTypeInformation - ModelLabel: -; Manufacturer: -; ProductionYear: dd.mm.rrrr
AC_Pset_RenovationAndPhasing - Renovation Status: New
